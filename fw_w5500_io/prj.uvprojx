# Keil uVision project prj.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: prj
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER, USE_OS
  c include: .\Codes\ST;.\Codes\BOOT;.\Codes\FreeRTOS;.\Codes\FreeRTOS\include;.\Codes\FreeRTOS\portable;.\Codes\cJSON;.\Codes\Wiznet;.\Codes\MEW;.\Codes\APP;.\Codes\MQTT;.\Codes\MQTTSN
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group ST
    ./Codes/ST/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group BOOT
    ./Codes/BOOT/: core_cm3.c core_cm3.h startup_stm32f10x_md.s stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h
  group Wiznet
    ./Codes/Wiznet/: w5500.c w5500.h wizchip_conf.c wizchip_conf.h socket.c socket.h loopback.c loopback.h
  group FreeRTOS/include
    ./Codes/FreeRTOS/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group FreeRTOS/portable
    ./Codes/FreeRTOS/portable/: heap_4.c port.c portmacro.h FreeRTOSConfig.h
  group FreeRTOS
    ./Codes/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group MQTTSN
    ./Codes/MQTTSN/: MQTTSNConnect.h MQTTSNConnectClient.c MQTTSNConnectServer.c MQTTSNDeserializePublish.c MQTTSNPacket.c MQTTSNPacket.h MQTTSNPublish.h MQTTSNSearch.h MQTTSNSearchClient.c MQTTSNSearchServer.c MQTTSNSerializePublish.c MQTTSNSubscribe.h MQTTSNSubscribeClient.c MQTTSNSubscribeServer.c MQTTSNUnsubscribe.h MQTTSNUnsubscribeClient.c MQTTSNUnsubscribeServer.c StackTrace.h
  group cJSON
    ./Codes/cJSON/: cJSON.c cJSON.h cJSON_Utils.c cJSON_Utils.h
  group APP
    ./Codes/APP/: main.c mew_board.c mew_board.h task_udp.c task_udp.h task_relay.c task_relay.h mew_iic.c mew_iic.h
