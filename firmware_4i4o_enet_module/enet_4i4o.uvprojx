# Keil uVision project enet_4i4o.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: enet_4i4o +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Sources\cmsis;.\Sources\stlib;.\Sources\bsp;.\Sources\app;.\Sources\freertos;.\Sources\freertos\include;.\Sources\freertos\portable
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group cmsis
    ./Sources/cmsis/: core_cm0.h core_cmFunc.h core_cmInstr.h
  group stlib
    ./Sources/stlib/: stm32f0xx_adc.c stm32f0xx_adc.h stm32f0xx_can.c stm32f0xx_can.h stm32f0xx_cec.c stm32f0xx_cec.h stm32f0xx_comp.c stm32f0xx_comp.h stm32f0xx_crc.c stm32f0xx_crc.h stm32f0xx_crs.c stm32f0xx_crs.h stm32f0xx_dbgmcu.c stm32f0xx_dbgmcu.h stm32f0xx_dma.c stm32f0xx_dma.h stm32f0xx_exti.c stm32f0xx_exti.h stm32f0xx_flash.c stm32f0xx_flash.h stm32f0xx_gpio.c stm32f0xx_gpio.h stm32f0xx_i2c.c stm32f0xx_i2c.h stm32f0xx_iwdg.c stm32f0xx_iwdg.h stm32f0xx_misc.c stm32f0xx_misc.h stm32f0xx_pwr.c stm32f0xx_pwr.h stm32f0xx_rcc.c stm32f0xx_rcc.h stm32f0xx_rtc.c stm32f0xx_rtc.h stm32f0xx_spi.c stm32f0xx_spi.h stm32f0xx_syscfg.c stm32f0xx_syscfg.h stm32f0xx_tim.c stm32f0xx_tim.h stm32f0xx_usart.c stm32f0xx_usart.h stm32f0xx_wwdg.c stm32f0xx_wwdg.h
  group freertos
    ./Sources/freertos/: event_groups.c list.c queue.c tasks.c timers.c
  group freertos/include
    ./Sources/freertos/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h partest.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group freertos/portable
    ./Sources/freertos/portable/: FreeRTOSConfig.h heap_1.c port.c portmacro.h
  group bsp
    ./Sources/bsp/: bsp.c bsp.h stm32f0xx_it.c stm32f0xx_it.h system_stm32f0xx.c system_stm32f0xx.h stm32f0xx_conf.h stm32f0xx.h startup_stm32f0xx.s
  group app
    ./Sources/app/: main.c buff.c buff.h app.c app.h
